# Required for generating DBus bindings for use with BlueZ
RDEPENDS_${PN} += "glib-2.0-codegen"
