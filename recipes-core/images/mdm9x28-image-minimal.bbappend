# run btattach on startup for mangOH Yellow
IMAGE_INSTALL += "start-scripts-mangoh-yellow-bt"
IMAGE_INSTALL += "start-scripts-mangoh-yellow-wifi-off"

